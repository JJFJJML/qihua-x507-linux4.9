## kernel/linux-4.9/drivers/fm/Kconfig
```kconfig
config BK1088_FM
	tristate "bk1088 i2c driver."
	default y
	help	
		bk1088 driver
```
